require u-boot-ti.inc

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"

PR = "r33"

BRANCH = "ti-u-boot-2021.01"

SRCREV = "9e33c11f9ed4e96a7379472491c965f0460c7f2b"
