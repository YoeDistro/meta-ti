require u-boot-ti.inc

BRANCH = "ti-u-boot-2017.01"

SRCREV = "d31a991ba516f814b340e0b0d280624ca902d563"
