require u-boot-ti.inc

PR = "r28"

BRANCH = "ti-u-boot-2019.01"

SRCREV = "964fa245a2919a6d4783211efa5dddd1df10e80f"
