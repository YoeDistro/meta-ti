require u-boot-ti.inc

PR = "r28"

BRANCH = "ti-u-boot-2020.01"

SRCREV = "71ba4a5f933a1f03e8bb72d487a62a877c2135ff"
