COMPATIBLE_MACHINE = "omap4|omap-a15"

EXTRA_OECONF += "--enable-omap-experimental-api"
