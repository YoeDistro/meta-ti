RDEPENDS_${PN}-tests_ti-soc += "bash"
