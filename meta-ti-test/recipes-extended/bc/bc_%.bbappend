
RM_WORK_EXCLUDE += "${PN}"

