PIGLIT_TI = ""
PIGLIT_TI:ti-soc = "piglit-ti.inc"

require ${PIGLIT_TI}
