LIBSDL2_TI = ""
LIBSDL2_TI:ti-soc = "libsdl2-ti.inc"

require ${LIBSDL2_TI}
