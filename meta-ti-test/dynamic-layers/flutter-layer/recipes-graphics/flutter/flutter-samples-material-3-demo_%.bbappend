FLUTTER_TI = ""
FLUTTER_TI:ti-soc = "flutter-samples-material-3-demo-ti.inc"

require ${FLUTTER_TI}
