FLUTTER_TI = ""
FLUTTER_TI:ti-soc = "flutter-wayland-client-ti.inc"

require ${FLUTTER_TI}
