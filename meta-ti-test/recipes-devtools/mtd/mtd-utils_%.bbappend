MTD_UTILS_TI = ""
MTD_UTILS_TI:ti-soc = "mtd-utils-ti.inc"

require ${MTD_UTILS_TI}
