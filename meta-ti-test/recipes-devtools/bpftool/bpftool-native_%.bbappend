BPFTOOL_NATIVE_TI = ""
BPFTOOL_NATIVE_TI:ti-soc = "bpftool-native-ti.inc"

require ${BPFTOOL_NATIVE_TI}
