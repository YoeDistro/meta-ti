
PM_QA_TI = ""
PM_QA_TI:ti-soc = "pm-qa-ti.inc"

require ${PM_QA_TI}

