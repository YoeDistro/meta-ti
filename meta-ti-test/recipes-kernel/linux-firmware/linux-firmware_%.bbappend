LINUX_FIRMWARE_TI = ""
LINUX_FIRMWARE_TI:ti-soc = "linux-firmware-ti.inc"

require ${LINUX_FIRMWARE_TI}
