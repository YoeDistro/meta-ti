KERNEL_SELFTEST_TI = ""
KERNEL_SELFTEST_TI:ti-soc = "kernel-selftest-ti.inc"

require ${KERNEL_SELFTEST_TI}
