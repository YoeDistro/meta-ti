COREMARK_TI = ""
COREMARK_TI:ti-soc = "coremark-ti.inc"

require ${COREMARK_TI}
