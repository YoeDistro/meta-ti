NBENCH_BYTE_TI = ""
NBENCH_BYTE_TI:ti-soc = "nbench-byte-ti.inc"

require ${NBENCH_BYTE_TI}
