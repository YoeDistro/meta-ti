COMPATIBLE_MACHINE_ti-soc = "ti-soc"
