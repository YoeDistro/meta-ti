FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}-${PV}:"
