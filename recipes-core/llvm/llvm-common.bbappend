PR_append = "-ti0"

SYSROOT_PREPROCESS_FUNCS_append_class-nativesdk = " llvm_common_sysroot_preprocess"

BBCLASSEXTEND += "nativesdk"
