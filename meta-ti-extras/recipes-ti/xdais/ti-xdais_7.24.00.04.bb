require ti-xdais.inc

PV = "7_24_00_04"
PR = "r1"

LIC_FILES_CHKSUM = "file://xdais_7_24_00_04_Manifest.html;md5=fd16442230745f0877cfe1c622669fd6"

SRC_URI[xdaistarball.md5sum] = "f7514085b531f2ae49b37b30194e4989"
SRC_URI[xdaistarball.sha256sum] = "79fd30377ab4c497292aeefb0565f81703d9020d1242b02ca9968c561e0de9a1"
