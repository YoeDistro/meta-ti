require ti-xdais.inc

PV = "6_26_01_03"
PR = "r1"

LIC_FILES_CHKSUM = "file://xdais_6_26_01_03_manifest.html;md5=a5a675d49db2f658bb98746ec80cda4e"

SRC_URI[xdaistarball.md5sum] = "9b2bea3408254e737ec0d819a031adf6"
SRC_URI[xdaistarball.sha256sum] = "d7bcbd8bcfe6fdfc5f402e4b125ced6c806dc30bc5296e98d5d43b0b5a237a0d"
