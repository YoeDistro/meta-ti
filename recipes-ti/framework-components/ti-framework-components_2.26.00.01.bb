require ti-framework-components.inc

PV = "2_26_00_01"
PR = "r2"

LIC_FILES_CHKSUM = "file://framework_components_2_26_00_01_manifest.html;md5=3250f9da7ee72284c07f8dd840400c75"

SRC_URI[fctarball.md5sum] = "40b51cade2f9ae6e6f6dca73c17065af"
SRC_URI[fctarball.sha256sum] = "3f7a12a51dfe87310828a31518d7ef8f9039e59269c0ca24f74a68433c235048"
