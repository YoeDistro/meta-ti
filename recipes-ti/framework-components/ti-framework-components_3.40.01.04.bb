require ti-framework-components.inc

PV = "3_40_01_04"
PR = "r0"

LIC_FILES_CHKSUM = "file://framework_components_${PV}_Manifest.html;md5=806c3e4afd3bfbf7e5dc400ed1a0cc3c"

SRC_URI[fctarball.md5sum] = "0e6b61cb6e1ad8b249d64f041c872192"
SRC_URI[fctarball.sha256sum] = "eb38002092a7fc8f704fe9ea9de7f29108bc2533ba95f184706b2936dd24711c"
