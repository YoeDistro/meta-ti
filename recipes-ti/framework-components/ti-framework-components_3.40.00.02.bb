require ti-framework-components.inc

PV = "3_40_00_02"
PR = "r1"

LIC_FILES_CHKSUM = "file://framework_components_${PV}_Manifest.html;md5=e3ce0b3e17175b7200f346d0c6dbbcc6"

SRC_URI[fctarball.md5sum] = "f66cb201582e1f407b92501d64738047"
SRC_URI[fctarball.sha256sum] = "91b0e571b8760e51e4683b44ce13ff3d2f6deb39b204e09894c30514f10c60db"
