require imglib-c66x.inc

PV = "3_1_1_0"
PR = "r1"

LIC_FILES_CHKSUM = "file://packages/ti/imglib/src/common/IMG_profile.h;beginline=1;endline=35;md5=a21fc16da34b650ce33a9a7143908667"

SRC_URI[imglib.md5sum] = "9d64f213e040899048446df5055deeca"
SRC_URI[imglib.sha256sum] = "f3153e51530f26cfc638efca7ca6ae1bbaf7736daf287fc972592372a676ed21"
