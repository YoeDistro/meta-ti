require dsplib-c66x.inc

PV = "3_4_0_0"
PR = "r1"

LIC_FILES_CHKSUM = "file://packages/ti/dsplib/dsplib.h;beginline=9;endline=35;md5=17733f9e1100f8a628512f47c4bf676a"

SRC_URI[dsplib.md5sum] = "66785604729c153dcad5282097dee8bf"
SRC_URI[dsplib.sha256sum] = "e88909b6271ce6c4c62e2ab90181b7adb36c7f28f5c52836668eb35888785ce8"
