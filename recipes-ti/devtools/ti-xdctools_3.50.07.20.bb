require recipes-ti/devtools/ti-xdctools-core.inc

PV = "3_50_07_20"
PR = "r0"

LIC_FILES_CHKSUM = "file://docs/license/xdc/shelf/package.html;beginline=1;endline=140;md5=1796f68c3d32d408415f5612f1f60652"

SRC_URI[xdczip.md5sum] = "52e4b5ddf2e004c6acff52104840724e"
SRC_URI[xdczip.sha256sum] = "bef631c110ca9243790de06cd51839170d7979b92e01396e4265009776ff7a07"
