include ti-cgt-arm.inc

LIC_FILES_CHKSUM = "file://ti-cgt-arm_${PV}.LTS/README.txt;md5=3faed35326711d6596f0377279323df1"

BINFILE_MD5 = "d0559bccc323002a9256dd68e1d223ab"
BINFILE_SHA256 = "8462eb7ce837274582721ed75c73928865d7678aca23b30fde962cdd36c21414"
