require recipes-ti/devtools/ti-xdctools-core.inc

PV = "3_50_03_33"
PR = "r0"

LIC_FILES_CHKSUM = "file://docs/license/xdc/shelf/package.html;beginline=1;endline=140;md5=1796f68c3d32d408415f5612f1f60652"

SRC_URI[xdczip.md5sum] = "21310b647275a7c7dd5b37dcb96c0b1b"
SRC_URI[xdczip.sha256sum] = "afe8616773e63b01e79e8cfacaf4d2c8d3b92c798c7f8cf5d1c7b5fe2060bbe4"
