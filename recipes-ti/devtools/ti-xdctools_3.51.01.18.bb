require recipes-ti/devtools/ti-xdctools-core.inc

PV = "3_51_01_18"
PR = "r0"

LIC_FILES_CHKSUM = "file://docs/license/xdc/shelf/package.html;beginline=1;endline=140;md5=7d8508a640d8e76fe372141df01c351f"

SRC_URI[xdczip.md5sum] = "54b80b603471623c1dbb0cfeb75b0fe2"
SRC_URI[xdczip.sha256sum] = "9bbbf433f0970bcb0cbf938615afe4d54420ecc56bc6e872f1a004338a8f19d5"
