require recipes-ti/devtools/ti-xdctools-core.inc

PV = "3_50_08_24"
PR = "r0"

LIC_FILES_CHKSUM = "file://docs/license/xdc/shelf/package.html;beginline=1;endline=140;md5=1796f68c3d32d408415f5612f1f60652"

SRC_URI[xdczip.md5sum] = "19e73ea981354e6fa7144978bc16e215"
SRC_URI[xdczip.sha256sum] = "335fd4050abba8e3c1c38d382d39a889441ef0d9bee57dba5892923acd586488"
