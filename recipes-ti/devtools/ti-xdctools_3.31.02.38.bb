require ti-xdctools-core.inc

PV = "3_31_02_38"
PR = "r0"

LIC_FILES_CHKSUM = "file://docs/license/xdc/shelf/package.html;md5=9dbb0095cdb8b35508b344aa4f1de333"

SRC_URI[xdczip.md5sum] = "c76b3d90c3e25d199765557e393d165b"
SRC_URI[xdczip.sha256sum] = "c0e1f6911f2294bfb76471fac1a0ceac3e89c7eb1300f84d2571bf78cb62a7d2"
