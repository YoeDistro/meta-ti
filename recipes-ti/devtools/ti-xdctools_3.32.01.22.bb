require recipes-ti/devtools/ti-xdctools-core.inc

PV = "3_32_01_22"
PR = "r0"

LIC_FILES_CHKSUM = "file://docs/license/xdc/shelf/package.html;beginline=1;endline=140;md5=1796f68c3d32d408415f5612f1f60652"

SRC_URI[xdczip.md5sum] = "ddae5b765ca62783c1e804c75c463c38"
SRC_URI[xdczip.sha256sum] = "b1c6620ef0b8eac45ef6a587f93b3238bdcf3b02dfd7e4b40d872a45c02c5cdc"
