require recipes-ti/devtools/ti-xdctools-core.inc

PE = "1"
PV = "3_55_02_22"
PR = "r0"

LIC_FILES_CHKSUM = "file://docs/license/xdc/shelf/package.html;beginline=1;endline=140;md5=2e742b9757bc9ce0241aadba9f627ab8"

SRC_URI[xdczip.md5sum] = "bb9154d677ce4724a5eac73817b23a0f"
SRC_URI[xdczip.sha256sum] = "bf90dfbbe298458c736d81d5631db25b335e79146923a4a50fab217e02723e7b"
