require ti-ipc-rtos.inc

PV = "3_40_01_08"
PR = "r0"

LIC_FILES_CHKSUM = "file://${S}/ipc-linux.mak;beginline=1;endline=30;md5=7b327f9b710fd7c95e545b91cec79255"

SRC_URI[ipczip.md5sum] = "738e1d54da9fab94899ad162f1ad78de"
SRC_URI[ipczip.sha256sum] = "8cc7d40ad7eab916eae109b355dc7e7876c6ab82e3b40bf5b6bf60474312d6cf"
