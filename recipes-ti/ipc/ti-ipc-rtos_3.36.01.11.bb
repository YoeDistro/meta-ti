require ti-ipc-rtos.inc

PV = "3_36_01_11"

LIC_FILES_CHKSUM = "file://${S}/ipc-linux.mak;beginline=1;endline=30;md5=7b327f9b710fd7c95e545b91cec79255"

SRC_URI[ipczip.md5sum] = "560a75d6291ba1467ab9e328b3f7b995"
SRC_URI[ipczip.sha256sum] = "ccf339a976a313c9f12cbdd91e74e7e0bc36507086b0cf077a344dcd79b9b273"
