require u-boot-ti-mainline_git.bb

SUMMARY = "U-Boot master-next for TI devices"

BRANCH = "master-next"
