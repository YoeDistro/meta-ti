WESTON_TI_VERSION = ""
WESTON_TI_VERSION:ti-soc = "${BPN}-ti-version.inc"

require ${WESTON_TI_VERSION}
