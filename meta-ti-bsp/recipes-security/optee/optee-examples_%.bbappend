PV:ti-soc = "3.20.0+git${SRCPV}"
SRCREV:ti-soc = "a98d01e1b9168eaed96bcd0bac0df67c44a81081"
SRC_URI = "git://github.com/linaro-swg/optee_examples.git;branch=master;protocol=https"
