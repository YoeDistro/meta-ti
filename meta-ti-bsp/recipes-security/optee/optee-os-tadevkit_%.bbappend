PV:ti-soc = "3.17.0+git${SRCPV}"
SRCREV:ti-soc = "15a746d28d10df3d79d72bc9fe4a5a654b88bcca"
