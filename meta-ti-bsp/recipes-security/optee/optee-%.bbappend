COMPATIBLE_MACHINE:ti-soc = "ti-soc"
