FILES:${PN}-staticdev:append:ti-soc = " ${libdir}/gprofng/*.a"
