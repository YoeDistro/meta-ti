SUMMARY = "TI RPMsg Char Utility Library"

require ti-rpmsg-char.inc

inherit autotools pkgconfig

PR = "r0"
