PIPEWIRE_TI = ""
PIPEWIRE_TI:ti-soc = "pipewire-ti.inc"

require ${PIPEWIRE_TI}
