
inherit gitpkgv
PKGV = "${PV}${GITPKGV}"
UBOOT_VERSION = "${PKGV}-${PKGR}"

