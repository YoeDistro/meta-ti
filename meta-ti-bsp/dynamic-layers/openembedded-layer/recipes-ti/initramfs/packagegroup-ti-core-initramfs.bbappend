RDEPENDS:${PN} += "\
    cifs-utils \
"
