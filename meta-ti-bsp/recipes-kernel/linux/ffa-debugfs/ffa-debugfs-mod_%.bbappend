# Added my meta-arm, this needs ceetain backports in 5.10
# Disable until kernel upgrades to newer than 5.10 where it
# is already upstreamed
# Revisit when kernel is upgraded to 5.15 or newer e.g.
COMPATIBLE_HOST:ti-soc = "null"
